
PACKAGECONFIG += " \
    dbus \
    linuxfb \
"

